# Repository dragino/Lora (continued)

## EAGLE design LT/LT-33222-L/v1.0/LT-33222-L v1.0.brd

Parts:
C1, C2, C8, C9: 110pf; C0402
C4, C7: 0.1uF; C0402
C5, C16: 22uF,10v; C1210
C6, C19: 10uf,50v; C1206
C10: 10uF,10V; SMC_A
C13: 2.7nf; C0402
C14: 0.1uf; C0402
D1, D7, D8, D19: SMBJ36CA; DO-214AA
D2, D4, D5, D6, D10: M7; DO214AC
D3, D9: ESD7951ST5G; SOD−923
IC1: ULN2003AD; SO16
K1, K2: HF46F-3-HS1
KEY1, KEY2: SWITCHDIL4; SWITCH_6X6X19_DIL4
L1: 1A; L1812
L4: PZ2012D301-1R5TF; C2012
L5: PZ2012D301-1R5TF; C0805
L6: 4.7uH /SWPA3015S4R7MT; SWPA3010S
LED1, LED2, LED3, LED4, LED5, LED6, LED7, LED8, LED9: RED; LED3MM
OK1, OK2, OK3: NEC2501; DIP4
P1: WJ2EDGRC-5.08-10P
P2: WJ2EDGRC-5.08-6P
Q1, Q2, Q3: 2SC3647; SOT-89
R1, R7: 12R 1%; R1206
R2: 75K 1%; R0402
R3: 24K 1%; R0402
R4: 100K; R0402
R5: 180K; R0402
R6: 16K 1%; R0402
R8, R9, R10, R17, R19, R20, R31: 1K 1%; R0402
R11, R13, R22, R26, R32, R34: 1K; R0402
R12, R21, R23, R24, R25, R27, R33: 10K; R0402
R14, R15: 3.24K 1%; R1206
R16, R18: 390K 1%; R1206
R28, R29: 4.7K; R0402
R30: 180Ω; R0402
U1: 74HC4052DA; SO16
U2: MCP3425; 6/SOT-23
U3: NGFF_M2_KEY_E_SHIELD
U4: RT7272; RT8250-SOP8
U5: PJ-325

Connections:
0V: D1.A (1), L5.1, P2.6
!RST: C7.2, KEY1.2, U3.53 (!RST)
+3V3: C5.1, C10.+, C14.2, C16.1, IC1.9 (CD+), K1.1, K2.1, L6.P$2 (4), R2.2, R11.1, R12.2, R22.1, R23.2, R25.1, R27.1, R28.2, R29.2, R30.1, R32.1, R33.2, R34.1, U1.16 (VCC), U2.5 (VDD), U3.2 (+3V3), U3.4 (+3V3), U3.72 (+3V3), U3.74 (+3V3)
BOOT0: KEY2.1, R21.1, U3.50 (BOOT0)
BOOT1: R24.2, U3.47 (PB2)
D_N: D9.P$1 (1), R25.2, U3.70 (PA2/USART2_TX), U5.2 (RXD)
D_P: D3.P$1 (1), R27.2, U3.68 (PA3/USART2_RX), U5.3 (TXD)
GND: C1.1, C2.1, C5.2, C6.2, C7.1, C8.1, C9.1, C10.-, C14.1, C16.2, C19.2, D2.A, D3.P$2 (2), D4.C, D5.A, D6.C, D7.A (1), D8.A (1), D9.P$2 (2), D19.A (1), IC1.8 (GND), KEY1.1, L5.2, LED1.K (C), LED5.K (C), LED6.K (C), OK1.3 (EMIT), OK2.3 (EMIT), OK3.3 (EMIT), Q1.E, Q2.E, Q3.E, R1.1, R3.1, R5.2, R6.1, R7.1, R14.1, R15.1, R21.2, R24.1, U1.1 (2Y0), U1.2 (2Y2), U1.4 (2Y3), U1.5 (2Y1), U1.6 (!E), U1.7 (VEE), U1.8 (GND), U2.2 (VSS), U2.6 (VIN-), U3.18 (GND), U3.57 (GND), U3.63 (GND), U3.75 (GND), U3.76 (PAD), U4.4 (GND), U4.9 (EPAD), U5.1 (GND)
IN1: D2.C, D4.A, P2.1, R1.2, R10.2
IN2: D5.C, D6.A, P2.2, R7.2, R8.2
IN3: P2.3, R16.2
IN4: P2.4, R18.2
IN5: OK1.2 (C), P1.6
IN6: OK2.2 (C), P1.5
IN7: OK3.2 (C), P1.4
unnamed: R14.2, R16.1, R17.2
unnamed: D1.C (2), D10.C, L1.1
unnamed: L1.2, L4.2
unnamed: LED1.A, R30.2
unnamed: LED8.A, R31.1
unnamed: LED2.A, R22.2
unnamed: IC1.16 (O1), K1.2
unnamed: LED3.A, R32.2
unnamed: R5.1, U4.7 (RLIM)
unnamed: C4.1, U4.2 (BOOT)
unnamed: LED3.K (C), OK1.1 (A)
unnamed: C13.1, R6.2
unnamed: LED2.K (C), OK2.1 (A)
unnamed: LED9.A, R9.1
unnamed: LED9.K (C), Q2.B
unnamed: LED7.A, R20.1
unnamed: LED7.K (C), Q3.B
unnamed: R15.2, R18.1, R19.2
unnamed: LED4.A, R11.2
unnamed: LED8.K (C), Q1.B
unnamed: KEY2.2, R34.2
unnamed: LED4.K (C), OK3.1 (A)
unnamed: C4.2, L6.P$1 (1), U4.1 (SW)
unnamed: R4.2, U4.3 (EN)
unnamed: LED6.A, R13.2
unnamed: C13.2, U4.6 (COMP)
unnamed: C6.1, C19.1, L4.1, R4.1, U4.8 (VIN)
unnamed: LED5.A, R26.2
unnamed: IC1.15 (O2), K2.2
unnamed: R2.1, R3.2, U4.5 (FB)
OUT1: C1.2, R10.1, U1.12 (1Y0)
OUT2: C2.2, R8.1, U1.14 (1Y1)
OUT3: C8.2, R17.1, U1.15 (1Y2)
OUT4: C9.2, R19.1, U1.11 (1Y3)
OUT5: D19.C (2), P1.3, Q1.C, Q1.C@1 (C)
OUT6: D7.C (2), P1.2, Q2.C, Q2.C@1 (C)
OUT7: D8.C (2), P1.1, Q3.C, Q3.C@1 (C)
OUT8: K1.4, P1.10
OUT9: K1.3 (S), P1.9
OUT10: K2.3 (S), P1.8
OUT11: K2.4, P1.7
PA0: IC1.2 (I2), R26.1, U3.67 (PA0)
PA1: IC1.1 (I1), R13.1, U3.65 (PA1)
PA8: OK3.4 (COL), R12.1, U3.20 (PA8)
PA9: OK1.4 (COL), R33.1, U3.32 (PA9/USART1_TX)
PA10: OK2.4 (COL), R23.1, U3.22 (PA10/USART1_RX)
PA12: R9.2, U3.3 (PA12/USB_DP)
PB12: R20.2, U3.10 (PB12/I2S2_WS)
PB14: R31.2, U3.14 (PB14/I2S2_MCK)
PB15: U3.12 (PB15/I2S2_SD)
S0: U1.10 (S0), U3.36 (PB3)
S1: U1.9 (S1), U3.48 (PB5)
SCL: R28.1, U2.3 (SCL), U3.60 (PB6/I2C1_SCL)
SDA: R29.1, U2.4 (SDA), U3.58 (PB7/I2C1_SDA)
V+: D10.A, P2.5
V_I_0UT: U1.13 (1Z), U2.1 (VIN+)

Notes on the sheet:
--> 3.3V
电压采样：IN3、IN4
开关量输入、NPN输出
电流采样：IN1、IN2
AD转换，I2C，双路四通道模拟选择器 2路电压采样（0-31.07V） 2路电流采样（0-21.3mA）
DC-DC转3.3V电源
继电器
启动方式设置：
ISP
RST
插座接口定义

Board: 2 copper layers, 95.9 x 63.0 mm, 92 parts (0 on the bottom side), 70 nets.

Other parts of the board:
U$1, U$5: LT-PCB-FRAME
U$2: LOGO-NEW; LOGO-SILK-NEW

## EAGLE design LoRaST/v2.0/LoRa ST v2.0.brd

Parts:
C6, C7: 5pF; C0402
C9, C10, C11, C12: 0.1uF 10V; C0402
IPEX1: I-PEX4
Q2: 8MHz; RESONATOR
Q3: 32.768KHz; 32.768K
R2: 0; R0402
R3: 1M; R0402
U2: NGFF_M2_KEY_E_CORE; LORA_ST_PCB
U3: STM32L072CZT6; LQFP48
U$2: LOGO-NEW; LOGO-SILK-NEW

Connections:
!RST: U2.53, U3.7 (NRST)
+3V3: C9.1, C10.1, C11.2, C12.2, U2.2, U2.4, U2.72, U2.74, U3.1 (VDD), U3.9 (VDDA), U3.24 (VDD), U3.36 (VDDIO2), U3.48 (VDD); also elsewhere on the board
ANT: IPEX1.SIG, R2.1; also elsewhere on the board
ANT2: R2.2
BOOT0: U2.50, U3.44 (BOOT0)
DIO0: U3.2 (PC13); also elsewhere on the board
DIO1: U3.21 (PB10); also elsewhere on the board
DIO2: U3.22 (PB11); also elsewhere on the board
DIO3: U3.45 (PB8); also elsewhere on the board
DIO4: U3.46 (PB9); also elsewhere on the board
DIO5: U3.19 (PB1); also elsewhere on the board
D_N: U2.5, U3.32 (PA11)
D_P: U2.3, U3.33 (PA12)
GND: C6.1, C7.1, C9.2, C10.2, C11.1, C12.1, IPEX1.GND1 (GND), IPEX1.GND2 (GND), IPEX1.GND3 (GND), Q2.2, U2.1, U2.18, U2.57, U2.63, U2.75, U2.76, U3.8 (VSSA), U3.23 (VSS), U3.35 (VSS), U3.47 (VSS); also elsewhere on the board
MISO: U3.16 (PA6); also elsewhere on the board
MOSI: U3.17 (PA7); also elsewhere on the board
unnamed: Q2.1, R3.2, U3.5 (PHO-OSC_IN)
unnamed: Q2.3, R3.1, U3.6 (PH1-OSC_OUT)
unnamed: C7.2, Q3.3 (1), U3.4 (PC15-OSC32_OUT)
unnamed: C6.2, Q3.4 (2), U3.3 (PC14-OSC32_IN)
NSS: U3.38 (PA15); also elsewhere on the board
PA0: U2.67, U3.10 (PA0)
PA1: U2.65, U3.11 (PA1)
PA2: U2.70, U3.12 (PA2)
PA3: U2.68, U3.13 (PA3)
PA4: U2.61, U3.14 (PA4)
PA8: U2.20, U3.29 (PA8)
PA9: U2.32, U3.30 (PA9)
PA10: U2.22, U3.31 (PA10)
PA13: U2.16, U3.34 (PA13)
PA14: U2.6, U3.37 (PA14)
PB2: U2.47, U3.20 (PB2)
PB3: U2.36, U3.39 (PB3)
PB4: U2.34, U3.40 (PB4)
PB5: U2.48, U3.41 (PB5)
PB6: U2.60, U3.42 (PB6)
PB7: U2.58, U3.43 (PB7)
PB12: U2.10, U3.25 (PB12)
PB13: U2.8, U3.26 (PB13)
PB14: U2.14, U3.27 (PB14)
PB15: U2.12, U3.28 (PB15)
RESET: U3.18 (PB0); also elsewhere on the board
SCK: U3.15 (PA5); also elsewhere on the board

Parts:
C2, C3, C4, C13, C15: 100nF; C0402
C5, C8: 24pF; C0402
C14, C17, C23, C25, C26: 47pF; C0402
C16: 10nF; C0402
C18, C20: 8.2pF; C0402
C19: 22pF; C0402
C21: 1.5pF; C0402
C22, C24: 3.3pF; C0402
C27, C28: 1nF; C0402
C29: 10uF; C0805
C30: 1uF; C0805
L1: 2.2nH; I-0402
L2: 33nH; I-0402
L3: 5.6nH; I-0402
L4: 4.7nH; I-0402
L5: 10nH; I-0402
Q1: 32MHz; SMD-3225_4P
Q4: BFS520; SOT323
R1: 10M; R0402
R4: 1K; R0402
R5: 0; R0402
R6: 1k; R0402
U1: RF_SWITCH; SC70-6
U4: SX1276; VQFN28_6X6MM

Connections:
+3V3: C3.2, C13.2, C14.2, C15.2, C29.2, C30.2, R1.1, U4.3 (VBAT1), U4.14 (VBAT3), U4.24 (VBAT2); also elsewhere on the board
ANT: C23.1; also elsewhere on the board
DIO0: U4.8 (DIO0); also elsewhere on the board
DIO1: U4.9 (DIO1); also elsewhere on the board
DIO2: U4.10 (DIO2); also elsewhere on the board
DIO3: U4.11 (DIO3); also elsewhere on the board
DIO4: U4.12 (DIO4); also elsewhere on the board
DIO5: U4.13 (DIO5); also elsewhere on the board
GND: C2.1, C3.1, C4.1, C5.1, C8.1, C13.1, C14.1, C15.1, C16.1, C17.1, C18.1, C20.1, C22.1, C24.1, C27.2, C28.1, C29.1, C30.1, Q1.2, Q1.4, Q4.3 (E), U1.2 (GND), U4.15 (GND), U4.23 (GND), U4.26 (GND), U4.29 (GND); also elsewhere on the board
MISO: U4.17 (MISO); also elsewhere on the board
MOSI: U4.18 (MOSI); also elsewhere on the board
unnamed: C5.2, Q1.1, U4.6 (XTB)
unnamed: C2.2, U4.4 (VR_DIG)
unnamed: C4.2, U4.2 (VR_ANA)
unnamed: C8.2, Q1.3, U4.5 (XTA)
unnamed: Q4.2 (B), R4.2
unnamed: C16.2, C17.2, L2.1, U4.25 (VR_PA)
unnamed: C26.1, U1.3 (RF2)
unnamed: L1.1, U4.27 (PA_BOOST)
unnamed: C26.2, R5.1
unnamed: C18.2, C19.2, L1.2 (4), L2.2 (4)
unnamed: C19.1, L3.1
unnamed: C20.2, C21.2, L3.2 (4), L4.1
unnamed: C21.1, C22.2, L4.2 (4), U1.1 (RF1)
unnamed: C23.2, U1.5 (RFC)
unnamed: C28.2, Q4.1 (C), R1.2, U1.6 (VDD)
unnamed: C25.1, R5.2
unnamed: C24.2, C25.2, L5.2 (4)
unnamed: L5.1, U4.21 (RFI_HF)
unnamed: C27.1, R6.1, U1.4 (CTRL)
unnamed: R4.1, R6.2, U4.20 (RXTX/RFMOD)
NSS: U4.19 (NSS); also elsewhere on the board
RESET: U4.7 (NRESET); also elsewhere on the board
SCK: U4.16 (SCK); also elsewhere on the board

Board: 4 copper layers, 42.0 x 22.0 mm, 51 parts (1 on the bottom side), 62 nets.

Other parts of the board:
U$1: LORA_ST

## EAGLE design LoRa G Dual/LoRa G-Dual v1.0.brd

Parts:
ANT1, ANT2: I-PEX
C1, C3: 0.1uF 10V; C0402
C12: 4.7uF 10V; C0402
C13: 22uF 6.3V; C0603@1
C14: NL; C0402
F1: MF-NSMF050-2 500mA; R1206
L2: 6.8uH SWPA3015S6R8MT; SWPA3010S
R1: 100K 1%; R0402
R2: 22.1k 1%; R0402
ROUTER1: MA08-2
SENSOR: MA07-2
U1, U4: RFM92_93W
U5: RT8059; SOT23-5

Connections:
+3V3: C1.2, C3.2, C13.1, C14.1, L2.P$2 (4), R1.2, U1.13 (3.3V), U4.13 (3.3V)
+5V: C12.1, F1.2, U5.1 (EN), U5.4 (VIN)
ANT: ANT2.SIG, U1.9 (ANT)
ANT_1: ANT1.SIG, U4.9 (ANT)
DIO0: SENSOR.10, U1.14 (DIO0)
DIO0_1: ROUTER1.7, U4.14 (DIO0)
DIO1: SENSOR.8, U1.15 (DIO1)
DIO1_1: ROUTER1.5, U4.15 (DIO1)
GND: ANT1.GND, ANT1.GND1 (GND), ANT2.GND, ANT2.GND1 (GND), C1.1, C3.1, C12.2, C13.2, R2.1, ROUTER1.4, ROUTER1.11, U1.1 (GND), U1.8 (GND), U1.10 (GND), U4.1 (GND), U4.8 (GND), U4.10 (GND), U5.2 (GND)
MISO: SENSOR.3, U1.2 (MISO)
MISO_1: ROUTER1.6, U4.2 (MISO)
MOSI: SENSOR.1, U1.3 (MOSI)
MOSI_1: ROUTER1.8, U4.3 (MOSI)
MS14_RESET: ROUTER1.3
unnamed: L2.P$1 (1), U5.3 (LX)
unnamed: C14.2, R1.1, R2.2, U5.5 (FB)
unnamed: F1.1, ROUTER1.2
NSS: SENSOR.4, U1.5 (NSS)
NSS_1: ROUTER1.12, U4.5 (NSS)
RESET: SENSOR.6, U1.6 (RESET)
RESET_1: ROUTER1.9, U4.6 (RESET)
SCK: SENSOR.2, U1.4 (SCK)
SCK_1: ROUTER1.10, U4.4 (SCK)
SENSOR_LED: ROUTER1.16
UART_RXD: ROUTER1.14
UART_TXD: ROUTER1.13

Notes on the sheet:
Sensor Connector to Screw Terminal
MOSI-GPIO16
MISO-GPIO26
SCK-GPIO14
NSS-GPIO15
RESET-GPIO08
DIO1-GPIO6
DIO0-GPIO7
MOSI_1-GPIO21
MISO_1-GPIO19
SCK_1-GPIO18
NSS_1-GPIO24
RESET_1-GPIO23
DIO0_1-GPIO22
DIO1_1-GPIO20

Board: 2 copper layers, 27.1 x 60.0 mm, 17 parts (1 on the bottom side), 22 nets.

Other parts of the board:
U$1: LOGO-DRAGINO-2018

## EAGLE design LSN50/v1.0/LoRa ST Sensor Node v1.0.brd

Parts:
C1, C2: 100pF 10V; C0603
C7: 0.1uF 10V; C0402
D1: SS14; DO214AC
JP1: PINHD-1X2POWER; 1X02-SMD
JP2: PINHD-1X2; 1X02
JP3: PINHD-1X12""; 1X12-DIP
JP4: PINHD-1X10""; 1X10-DIP
R1, R2, R3, R4, R5, R6, R8, R9, R10, R21, R24: 10K; R0402
R7: 4.7K; R0402
R11, R13: 0ohm; R0603
R12, R14: 10K; R0603
RESET: 轻触开关3*3*1.5四脚贴片开关; SW4-SMD-3.35X3.35X1.5MM
SW1: MSS22D-18G2-2P2T-H2MM; MSS22D-18G2-2P2T-H2MM-DIL
U1: NGFF_M2_KEY_E_SHIELD

Connections:
!RST: C7.2, RESET.A1, U1.53 (!RST)
+3V3: D1.C, JP3.1, JP4.10, R1.2, R2.2, R3.2, R4.2, R5.2, R7.2, R8.2, R9.2, R10.2, SW1.3, U1.2 (+3V3), U1.4 (+3V3), U1.72 (+3V3), U1.74 (+3V3)
BATTERY: JP1.1, JP2.1
BOOT0: R21.1, U1.50 (BOOT0)
D_N: JP4.2, U1.5 (PA11/USB_DM)
D_P: JP4.1, U1.3 (PA12/USB_DP)
GND: C1.1, C2.1, C7.1, JP1.2, JP3.2, JP4.9, R12.2, R14.2, R24.1, RESET.B1, SW1.1, U1.1 (GND), U1.18 (GND), U1.57 (GND), U1.63 (GND), U1.75 (GND), U1.76 (PAD)
unnamed: R24.2, SW1.4
unnamed: R21.2, SW1.2
PA0: JP3.12, U1.67 (PA0)
PA1: JP3.11, U1.65 (PA1)
PA2: JP3.10, R9.1, U1.70 (PA2/USART2_TX)
PA3: JP3.9, R10.1, U1.68 (PA3/USART2_RX)
PA4: R5.1, R6.1, U1.61 (PA4)
PA8: JP4.8, R11.2
PA8-I: C2.2, R11.1, R12.1, U1.20 (PA8)
PA9: JP3.4, R3.1, U1.32 (PA9/USART1_TX)
PA10: JP3.3, R4.1, U1.22 (PA10/USART1_RX)
PA13: JP4.7, U1.16 (PA13/SWDIO)
PA14: JP4.3, U1.6 (PA14/SWCLK)
PB2: SW1.5, U1.47 (PB2)
PB3: JP3.6, R7.1, U1.36 (PB3)
PB4: JP3.5, R8.1, U1.34 (PB4)
PB5: U1.48 (PB5)
PB6: JP3.8, R1.1, U1.60 (PB6/I2C1_SCL)
PB7: JP3.7, R2.1, U1.58 (PB7/I2C1_SDA)
PB12: JP4.4, U1.10 (PB12/I2S2_WS)
PB13: R6.2, U1.8 (PB13/I2S2_CK)
PB14: JP4.6, R13.2
PB14-I: C1.2, R13.1, R14.1, U1.14 (PB14/I2S2_MCK)
PB15: JP4.5, U1.12 (PB15/I2S2_SD)
VDD: D1.A, JP2.2

Notes on the sheet:
BOOT MODE
RST
POWER
PA4

Board: 2 copper layers, 58.0 x 43.5 mm, 29 parts (8 on the bottom side), 31 nets.

Other parts of the board:
U$1: LORA_ST_SENSOR_NODE
U$2: LOGO-NEW; LOGO-SILK-NEW

## Commit log

2016-03-24 :neckbeard: Added .gitattributes & .gitignore files
2016-03-24 Add Lora Shield Hardware
    Lora Shield hardwre update
2016-03-28 Add Skect Example
2016-05-03 add v1.3
2016-05-16 Reorganize directory structure
2016-05-23 Create Lora_GPS HAT for RPi
2016-05-23 Lora/GPS HAT
    The Dragino Lora/GPS_HAT is a expension module for LoRaWan for ues with the Raspberry Pi.This product is intended for those interested in developing LoRaWAN gateway solutions.
    The Lora/GPS HAT is based on the SX1276 transceiver.The add on L80 GPS is designed for applications that use a GPS connected via the serial ports to the Raspberry Pi such as timing applications or ge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
    The transceivers of the Lora/GPS HAT feature the LoRaTM long range modem that provides ultra-long range spread spectrum communication and high interference immunity whilst minimising current consumpt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
2016-05-23 Lora GPS HAT
    The Dragino Lora/GPS_HAT is a expension module for LoRaWan for ues with
    the Raspberry Pi.This product is intended for those interested in
    developing LoRaWAN gateway solutions.
    More info please
    click:http://wiki.dragino.com/index.php?title=Lora/GPS_HAT
2016-06-27 Revert "Lora GPS HAT"
    This reverts commit 4dc4bcfcb2a3df9f916603c6fb9521500b301c85.
2016-06-27 Revert "Revert "Lora GPS HAT""
    This reverts commit 788f78e7eb40f0d376849e86f10e894c99ca817f.
2016-06-30 Add Example
2016-07-14 Add Raw data example from LMIC library
2016-07-25 Add Lora GPS Shield product
    Add hardware source and examples.
2016-08-17 Add LoraWan 915Mhz example
2016-10-24 Update hardware design
    Lora Shield update to v1.4
    Lora GPS HAT update to v1.3
    changelog see wiki.dragino.com related product part
2017-03-06 Add LoRa mini hardware source
2017-03-06 Add LoRa mini source
2017-05-01 Add LoRa G hardware design.
    LoRa G is the module use in LG01 and OLG01
2017-06-22 Update LoRa Mini Dev v1.3 hardware source
2017-07-04 Add LoRa GPS Shield v1.3 hardware
2017-11-29 Add Source code for LSN50 and LoRaST
2018-09-13 Add LoRa G Dual Module
    LoRa module for LG02/OLG02
2018-09-19 Add LSN50 v1.2
    LSN50 v1.2 hardware source file.
2018-10-13 Add LoRa ST v2.0 design file
2018-10-15 Add LT-33222-L Hardware File
2019-01-06 Add LGT-92 Design File
2019-05-15 add LSN50 v1.3 hardware
2019-05-15 typo , fix
2019-07-16 LGT-92 v1.4 updtae
2020-01-14 Update LSN50 v2.0 firmware
2020-10-15 Update LGT92 v1.5hardware source
2021-12-06 Update LSn50v2 design files.
2023-01-10 Update LSN50v3 design
    Update LSN50v3 design
2023-01-28 Add LoRaST v4.1
2025-12-23 Updated schematic files for both version 3.3 and 3.3.1.
